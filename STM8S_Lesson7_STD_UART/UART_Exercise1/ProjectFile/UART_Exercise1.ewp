# IAR project UART_Exercise1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208C8 STM8S208C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S208
  ICCSTM8.CCIncludePath2: E:\STM8S\Project_IAR\STM8S_Lesson7_STD_UART\UART_Exercise1\DriverLib\inc; E:\STM8S\Project_IAR\STM8S_Lesson7_STD_UART\UART_Exercise1\UserFile
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: UART_Exercise1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group DriverLib
    ../DriverLib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c
  group User
    ../UserFile/: m_stm8s208_clk.c m_stm8s208_tim4.c m_stm8s208_uart1.c m_stm8s208_uart3.c main.c stm8s_it.c
